# Keil uVision project 1.uvprojx, settings and files
target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 1 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\APP;..\driver;..\HMI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c
  group APP
    ./: main.c
    ../APP/: motor.c QR701_Printer.c
  group HMI
    ../HMI/: hmi_driver.c cmd_queue.c hmi_process.c
  group driver
    ../driver/: delay.c hard_pwm.c stmflash.c pin.c usartx.c timer.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_dac.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c
  group ReadMe
    ../../: 说明.txt
